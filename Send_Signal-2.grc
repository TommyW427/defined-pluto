options:
  parameters:
    description: BPSK Pluto Transmitter - reads bits from file
    generate_options: qt_gui
    id: Send_Signal
    output_language: python
    title: BPSK Pluto Transmitter (File Source)
  states: {}

blocks:
- name: bit_file
  id: variable
  parameters:
    comment: Change this to use a different bit file
    value: '"bit_tests/bits_000.bin"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate // symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Reads uint8 bits (0 or 1) from file
    file: bit_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale to avoid clipping
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: Hold each symbol for sps samples
    interp: sps
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 'BPSK mapping: 0 -> -1+0j, 1 -> +1+0j'
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_plutosdr_sink_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
