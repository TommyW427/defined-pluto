options:
  parameters:
    description: BPSK PlutoSDR Receiver - Raw IQ collection for DEFINED pipeline
    generate_options: qt_gui
    id: Receive_Signal
    output_language: python
    title: BPSK Pluto Receiver - IQ Collection
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate // symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Raw IQ samples saved as complex float32
    file: received_iq.bin
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Spectrum view to verify signal presence
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    label: ''
    name: Received Spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Real part of received baseband
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: I (real)
    label2: Q (imag)
    name: Received Baseband
    size: '2500'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    dev_args: device='plutosdr'
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', blocks_file_sink_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
