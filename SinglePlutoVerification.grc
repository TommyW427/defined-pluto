options:
  parameters:
    generate_options: qt_gui
    id: SPV
    output_language: python
    title: Single Pluto Validation
  states: {}

blocks:
- name: bit_file
  id: variable
  parameters:
    comment: Change this to use a different bit file
    value: '"bit_tests/bits_000.bin"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Must match transmitter center frequency
    value: 915e6
  states: {}
- name: clock_bw
  id: variable_qtgui_range
  parameters:
    comment: Clock recovery speed. Adjust if symbols are smeared.
    gui_hint: 0,2,1,1
    label: Clock Recovery BW
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.045'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    comment: Frequency sync speed. Increase if constellation spins.
    gui_hint: 0,1,1,1
    label: Costas Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.0628'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: Adjust to get clean constellation without clipping
    gui_hint: 0,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must match transmitter sample rate
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samp_rate / symbol_rate = 25 samples per symbol
    value: int(samp_rate // symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Must match transmitter symbol rate
    value: '10000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Normalizes amplitude to 1.0 for consistent sync performance
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_raw
  id: blocks_file_sink
  parameters:
    comment: Raw IQ before any synchronization (for debugging)
    file: received_iq_raw.bin
    type: complex
  states: {}
- name: blocks_file_sink_symbols
  id: blocks_file_sink
  parameters:
    comment: 'Output: 1 complex sample per symbol, ready for detection'
    file: received_symbols.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Reads uint8 bits (0 or 1) from file
    file: bit_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale to avoid clipping
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: Hold each symbol for sps samples
    interp: sps
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 'BPSK mapping: 0 -> -1+0j, 1 -> +1+0j'
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Removes freq/phase offset. Order=2 for BPSK.
    order: '2'
    w: costas_bw
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Mueller & Mueller clock recovery. Outputs 1 sample/symbol.
    damping: '1.0'
    loop_bw: clock_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Should show two clusters at ±1 on real axis for BPSK
    grid: 'True'
    gui_hint: 1,0,1,2
    name: After Clock Recovery
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Check that the signal is present at the expected frequency
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,3
    label: ''
    name: Received Spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Real part should jump cleanly between -1 and +1
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: I (real)
    label2: Q (imag)
    name: Synchronized Symbols
    size: '200'
    srate: symbol_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    comment: Receives RF, outputs complex IQ at sample rate
    dev_args: device='plutosdr'
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_file_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_plutosdr_sink_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_symbols, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', analog_agc_xx_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_file_sink_raw, '0']
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
